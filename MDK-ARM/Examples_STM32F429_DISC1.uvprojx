# Keil uVision project Examples_STM32F429_DISC1.uvprojx, settings and files
target Examples_STM32F429_DISC1 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Examples_STM32F429_DISC1 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;C:/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Inc;C:/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/CMSIS/Include;../Libs;../Components;../Communication;../Adapters;../Controls
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dcmi.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libs/Common
    ../Libs/Common/: xCircleBuffer.c xCircleBuffer.h xDataBuffer.c xDataBuffer.h xMemory.c xMemory.h xRx.c xRx.h xRxReceiver.c xRxReceiver.h xRxRequest.c xRxRequest.h xRxTransaction.c xRxTransaction.h xTx.c xTx.h xTxTransfer.c xTxTransfer.h xTypes.h
  group Libs/Common/Adapters
    ../Libs/Common/Adapters/: xRxTransactionTransferAdapter.c xRxTransactionTransferAdapter.h
  group Libs/Registers
    ../Libs/Registers/registers_stm32f4xx/: registers_stm32f4xx_i2c.h registers_stm32f4xx_spi.h registers_stm32f4xx_timer.h registers_stm32f4xx_uart.h
    ../Libs/Registers/: registers.h
  group Libs/OV2640
    ../Libs/OV2640/: OV2640_BrightnessTables.h OV2640_ContrastTables.h OV2640_Driver.c OV2640_Driver.h OV2640_InitializationTables.h OV2640_JPEG_Tables.h OV2640_LightModeTables.h OV2640_PixelFormatsTables.h OV2640_Registers.h OV2640_ResolutionTables.h OV2640_SaturationTables.h OV2640_SpecialEffectsTables.h OV2640_xVGA_Tables.h
  group Libs/WS2812
    ../Libs/WS2812/: WS2812.c WS2812.h WS2812_Config.h WS2812_Info.h WS2812_DrawManagerBase.c WS2812_DrawManagerBase.h
  group Components
    ../Components/: Components.h Components_Config.h
  group Components/Terminal
    ../Components/Terminal/Controls/: Terminal.c Terminal.h
    ../Components/Terminal/: Terminal_Component.c Terminal_Component.h Terminal_Config.h Terminal_Info.h Terminal_Types.h
  group Components/Terminal/Adapters
    ../Components/Terminal/Adapters/: README.md Terminal_Adapters.h Terminal_TransferAdapter.c Terminal_TransferAdapter.h
  group Components/Terminal/Communication
    ../Components/Terminal/Communication/: Terminal_RxRequests.c Terminal_RxRequests.h Terminal_RxTransactions.c Terminal_RxTransactions.h
  group Components/SerialPort
    ../Components/SerialPort/: SerialPort_Config.h SerialPort_Info.h SerialPort_Types.h SerialPort_UART_Component.c SerialPort_UART_Component.h
    ../Components/SerialPort/Controls/: SerialPort.c SerialPort.h
  group Components/SerialPort/Adapters
    ../Components/SerialPort/Adapters/UART/: SerialPort_UART_Adapter.c SerialPort_UART_Adapter.h SerialPort_UART_AdapterConfig.h SerialPort_UART_AdapterInfo.h SerialPort_UART_AdapterTypes.h SerialPort_UART_RxAdapter.c SerialPort_UART_RxAdapter.h SerialPort_UART_TxAdapter.c SerialPort_UART_TxAdapter.h
  group Components/Camera
    ../Components/Camera/: Camera_Config.h Camera_Info.h Camera_Types.h Camera_OV2640_Component.c Camera_OV2640_Component.h
    ../Components/Camera/Controls/: Camera.c Camera.h Camera_AdapterBase.c Camera_AdapterBase.h
  group Components/Camera/Adapters
    ../Components/Camera/Adapters/OV2640/: Camera_OV2640_Adapter.c Camera_OV2640_Adapter.h Camera_OV2640_AdapterConfig.h Camera_OV2640_AdapterInfo.h Camera_OV2640_AdapterInterface.c Camera_OV2640_AdapterTypes.h
  group Components/Camera/Communications
    ../Components/Camera/Communications/: Camera_Requests.c Camera_Requests.h Camera_Transactions.c Camera_Transactions.h
  group Components/CupsController
    ../Components/CupsController/: CupsController_Component.c CupsController_Component.h CupsController_Config.h CupsController_Info.h CupsController_Types.h
    ../Components/CupsController/Controls/: CupsController.c CupsController.h CupsController_DrawManager.c CupsController_DrawManager.h CupsController_LEDBase.c CupsController_LEDBase.h CupsController_HeaterBase.c CupsController_HeaterBase.h CupsController_FlowDirectorBase.c CupsController_FlowDirectorBase.h
  group Components/CupsController/Adapters
    ../Components/CupsController/Adapters/LED/: CupsController_LEDAdapter.c CupsController_LEDAdapter.h CupsController_LEDAdapterTypes.h
  group Components/CupsController/Communications
    ../Components/CupsController/Communications/: CupsController_RxRequests.c CupsController_RxRequests.h CupsController_RxTransactions.c CupsController_RxTransactions.h
  group Components/Carousel
    ../Components/Carousel/: Carousel_Component.c Carousel_Component.h Carousel_Config.h Carousel_Info.h Carousel_Types.h
    ../Components/Carousel/Controls/: Carousel.c Carousel.h Carousel_MotorBase.c Carousel_MotorBase.h
  group Components/Carousel/Adapters
    ../Components/Carousel/Adapters/DCMotor/: Carousel_DCMotorAdapter.c Carousel_DCMotorAdapter.h Carousel_DCMotorAdapterConfig.h Carousel_DCMotorAdapterTypes.h
  group Components/Carousel/Communications
    ../Components/Carousel/Communications/: Carousel_RxRequests.c Carousel_RxRequests.h Carousel_RxTransactions.c Carousel_RxTransactions.h
  group Components/Slider
    ../Components/Slider/: Slider_Component.c Slider_Component.h Slider_Config.h Slider_Info.h Slider_Types.h
    ../Components/Slider/Controls/: Slider.c Slider.h
  group Components/Slider/Adapters
    ../Components/Slider/Adapters/: Slider_AdapterBase.c Slider_AdapterBase.h Slider_Adapters.h Slider_AdaptersConfig.h
    ../Components/Slider/Adapters/DCMotor/: Slider_DCMotorAdapter.c Slider_DCMotorAdapter.h Slider_DCMotorAdapterConfig.h Slider_DCMotorAdapterTypes.h
  group Components/Slider/Communications
    ../Components/Slider/Communications/: Slider_RxRequests.c Slider_RxRequests.h Slider_RxTransactions.c Slider_RxTransactions.h
  group Components/BrewGroup
    ../Components/BrewGroup/: BrewGroup_Component.c BrewGroup_Component.h BrewGroup_Config.h BrewGroup_Info.h BrewGroup_Types.h
    ../Components/BrewGroup/Controls/: BrewGroup.c BrewGroup.h BrewGroup_MotorBase.c BrewGroup_MotorBase.h BrewGroup_ThermostatBase.c BrewGroup_ThermostatBase.h BrewGroup_WaterPumpBase.c BrewGroup_WaterPumpBase.h
  group Components/BrewGroup/Adapters
    ../Components/BrewGroup/Adapters/DCMotor/: BrewGroup_DCMotorAdapter.c BrewGroup_DCMotorAdapter.h BrewGroup_DCMotorAdapterConfig.h BrewGroup_DCMotorAdapterTypes.h
    ../Components/BrewGroup/Adapters/Thermostat/: BrewGroup_ThermostatAdapter.c BrewGroup_ThermostatAdapter.h BrewGroup_ThermostatAdapterConfig.h BrewGroup_ThermostatAdapterTypes.h
    ../Components/BrewGroup/Adapters/WaterPump/: BrewGroup_WaterPumpAdapter.c BrewGroup_WaterPumpAdapter.h BrewGroup_WaterPumpAdapterConfig.h BrewGroup_WaterPumpAdapterTypes.h
  group Components/BrewGroup/Communications
    ../Components/BrewGroup/Communications/: BrewGroup_RxRequests.c BrewGroup_RxRequests.h BrewGroup_RxTransactions.c BrewGroup_RxTransactions.h
software components: CMSIS:CORE 5.6.0
